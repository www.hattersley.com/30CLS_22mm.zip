# Autodesk Inventor part: 30CLS_22mm
## iProperties
Created: 2011-03
Part Number: 30CLS_22mm
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
